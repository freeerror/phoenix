# IAR project SU_driver_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L162xD ST STM32L162xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MDP
  ICCARM.CCIncludePath2: ..\..\User\bsp\inc; ..\..\User\bsp; ..\..\User\app\inc; ..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\FreeRTOS\include; ..\..\FreeRTOS\portable\IAR\ARM_CM3; ..\..\User
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\User
  OBJCOPY.OOCOutputFile: SU_driver_IAR.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: SU_driver_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP
    ../../User/bsp/src/: adxl345.c beep.c I2c.c nt3h1101.c opt3001.c platform.c SHT20.c usart.c WS2812.c
    ../../User/bsp/: bsp.c stm32l1xx_it.c
  group CMSIS
    ../../User/bsp/: system_stm32l1xx.c
  group DOC
    ../../Doc/: 01.例程功能说明.txt 02.开发环境说明.txt
  group EWARMv7
    ../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_mdp.s
  group FreeRTOS/Ports
    ../../User/: heap_4.c port.c portasm.s portmacro.h
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group HAL
    ../../User/bsp/src/: hal_acc_sensor.c hal_beep.c hal_brightness.c hal_led.c hal_nfc.c hal_platform.c hal_tempRh.c
  group StdPeriph_Driver
    ../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group User
    ../../User/: FreeRTOSConfig.h includes.h
    ./: main.c
