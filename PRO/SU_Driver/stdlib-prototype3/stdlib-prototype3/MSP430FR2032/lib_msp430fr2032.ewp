# IAR project lib_msp430fr2032.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR2032 MSP430FR2032
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: driverlib\MSP430FR2xx_4xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr2032.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
  group driverlib
    driverlib/MSP430FR2xx_4xx/: adc.c adc.h crc.c crc.h cs.c cs.h driverlib.h ecomp.c ecomp.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h gpio.c gpio.h lcd_e.c lcd_e.h mpy32.c mpy32.h pmm.c pmm.h rtc.c rtc.h sac.c sac.h sfr.c sfr.h sysctl.c sysctl.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h tri.c tri.h wdt_a.c wdt_a.h
  group driverlib/inc
    driverlib/MSP430FR2xx_4xx/inc/: hw_memmap.h version.h
