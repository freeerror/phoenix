# Keil uVision project stm32l162_sensing_box.uvprojx, settings and files
target stm32l162_sensing_box (ARM-ADS)
  device: STM32L151VC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32l162_sensing_box +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L1XX_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32L1xx_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAL_Drivers\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c stm32l1xx_it.c system_stm32l1xx.c GPIO.c SPI.c SX1276.c WS2812.c I2c.c SHT20.c opt3001.c adxl345.c nt3h1101.c usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32l1xx_hd.s
  group FWLIB
    ../STM32L1xx_FWLib/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
